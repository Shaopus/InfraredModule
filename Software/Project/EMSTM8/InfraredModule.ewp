# IAR project InfraredModule.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G4 STM8L151G4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\Library\STM8L15x_StdPeriph_Driver\inc; ..\..\CC1101_LIB
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: InfraredModule.hex
  ILINK.IlinkOutputFile: InfraredModule.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group CC1101_LIB
    ../../CC1101_LIB/: CC1101.c
  group STM8L15x_StdPeriph_Driver
    ../../Library/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
  group USER
    ../src/: adc.c delay.c main.c spi.c stm8l15x_it.c
